# Keil uVision project STM32_FOC_PMSM.uvprojx, settings and files
target BOOT_FLASH (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BOOT_FLASH +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\..\STM32F10XFWLIB\inc;..\inc;..\;..\Head;..\OLED
  asm include: ..\Head
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group RVMDK
    ./: stm32f10x_vector.s cortexm3_macro.s
  group Source
    ../: stm32f10x_it.c
    ../src/: main.c MC_Clarke_Park.c MC_FOC_Drive.c MC_MotorControl_Layer.c MC_Globals.c MC_PID_regulators.c MC_State_Observer_Interface.c MC_Keys.c MC_Display.c stm32f10x_encoder.c stm32f10x_hall.c stm32f10x_Timebase.c stm32f10x_MCdac.c stm32f10x_svpwm_3shunt.c stm32f10x_svpwm_ics.c stm32f10x_svpwm_1shunt.c Key.c ili2302lcd.c DISPLAY.c
  group Parameters .h files
    ../inc/: STM32F10x_MCconf.h MC_Control_Param.h MC_encoder_param.h MC_hall_prm.h MC_PMSM_motor_param.h MC_State_Observer_param.h MC_pwm_1shunt_prm.h MC_pwm_3shunt_prm.h
  group Lib
    ./lib/: MC_FOC_Methods_lib.lib MC_State_Observer_lib.lib
  group STM32F10XFWLIB
    ../../STM32F10XFWLIB/src/: stm32f10x_wwdg.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dbgmcu.c stm32f10x_fsmc.c
    ../src/: stm32f10x_dac.c
  group Doc
    ./: readme.txt
  group HEAD
    ../Head/: Ram.h STM103REG.h TYPESTRUCT.h
  group OLED
    ../OLED/: core_cm3.c lkznui.c oled.c
